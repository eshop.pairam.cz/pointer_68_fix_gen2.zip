Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Pointer 68 fix GEN2.IFC
Time: 2022-04-28T12:27:17
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Pointer 68 fix GEN2
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
